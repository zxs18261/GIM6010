# Keil uVision project GIM6010_V0.0.uvprojx, settings and files
target GIM6010_V0.0 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GIM6010_V0_0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../BSP;../APP;../SguanFOC V3.0.1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../BSP/: BSP_ADC.c BSP_ADC.h BSP_MT6816.c BSP_MT6816.h BSP_WS2812B.c BSP_WS2812B.h bsp_flash.c bsp_flash.h
  group APP
    ../APP/: app_can.c app_autotune.c app_protocol.c app_can.h app_autotune.h app_protocol.h app_api.h
  group SguanFOC
    ../SguanFOC V3.0.1/: Sguan_Config.h Sguan_Filter.c Sguan_Filter.h Sguan_IQmath.c Sguan_IQmath.h Sguan_MotorStatus.c Sguan_MotorStatus.h Sguan_Optimize.c Sguan_Optimize.h Sguan_PID.c Sguan_PID.h Sguan_PLL.c Sguan_PLL.h Sguan_printf.c Sguan_printf.h Sguan_STA.c Sguan_STA.h Sguan_SVPWM.c Sguan_SVPWM.h SguanFOC.c SguanFOC.h UserData_Config.h UserData_Function.h UserData_Motor.h UserData_Parameter.h UserData_Status.h UserData_UserControl.h
software components: CMSIS:CORE 4.3.0
